# Keil uVision project project.uvprojx, settings and files
target rtthread-minifly (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread-stm32
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: RT_USING_ARM_LIBC, USE_STDPERIPH_DRIVER
  c include: applications;.;drivers;Libraries\STM32F10x_StdPeriph_Driver\inc;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;rt-thread\components\CMSIS\Include;rt-thread\include;rt-thread\libcpu\arm\cortex-m3;rt-thread\libcpu\arm\common;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\libc\compilers\armlibc;.\Framework\include;.\System;.\3pp;.\USB\CONFIG;.\USB\STM32_USB-FS-Device_Driver\inc;.\GUI\APP\interface;.\GUI\DRV\interface
  memory RVCT4: ROM 0x8002400 size 0x3dc00
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: application.c startup.c canapp.c
  group Drivers
    drivers/: board.c stm32f10x_it.c led.c usart.c gpio.c bxcan.c
    ./drivers/: 24l01.c stmflash.c oled.c adc.c
  group STM32_StdPeriph
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_rtc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_cec.c misc.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Kernel
    ./rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group CORTEX-M3
    ./rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ./rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group Filesystem
    ./rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ./rt-thread/components/dfs/filesystems/devfs/: devfs.c
    ./rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group DeviceDrivers
    ./rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
    ./rt-thread/components/drivers/can/: can.c
    ./rt-thread/components/drivers/misc/: pin.c
    ./rt-thread/components/drivers/serial/: serial.c
  group finsh
    ./rt-thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group libc
    ./rt-thread/components/libc/compilers/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
  group Framework
    ./Framework/src/: atkp.c config_param.c display.c keyTask.c radiolink.c remoter_ctrl.c usblink.c joystick.c beep.c
  group System
    ./System/: system.c debug_assert.c
  group 3pp
    ./3pp/: font.c
  group usb
    ./USB/CONFIG/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
    ./USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group gui
    ./GUI/APP/src/: debug_ui.c joystickCalib_ui.c main_ui.c match_ui.c menu_ui.c menuL1_item.c menuL2_item.c menuL3_item.c reset_ui.c trim_ui.c
    ./GUI/DRV/src/: button.c gui_basic.c gui_menu.c lcmdrv.c messagebox.c scrollbar.c text.c windows.c
